IMAGE_INSTALL += " bbexample"

IMAGE_INSTALL += " keymaps"
IMAGE_INSTALL += " cronie"

IMAGE_INSTALL += "can-commander"
